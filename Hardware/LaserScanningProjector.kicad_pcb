# Repository waicool20/LaserScanningProjector

File README.md:

# Laser Scanning Projector

Use a scanning laser to draw images onto a surface!

## Project Structure

- `Hardware`: Contains PCB schematics and STM32CubeMX IOC file
- `Software`: Software for the MCU
- `Software-PC`: PC-side software for streaming USB data
- `Report`: Report for submission to course

# License

Hardware: Creative Commons Attribution-ShareAlike 4.0 International

Software: MIT

## KiCad design Hardware/LaserScanningProjector.kicad_pcb

Parts:
C1, C3, C5, C7, C8, C9, C11, C12, C13, C14, C15, C16: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C4: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6, C10: 22p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad
J1: 5V_IN; PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal
J2: SWD; PinHeader_1x04_P2.54mm_Vertical
J3: UART; PinHeader_1x04_P2.54mm_Vertical
J4: USB_B
J5: LCD
J6: Micro_SD_Card_Det; Micro_SD
J7: AUX; PinHeader_2x02_P2.54mm_Vertical
R1, R2: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4, R5, R6, R7, R26: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8, R9: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10, R11, R12: 47k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13: LDR_DETECT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
RV1: 10k; Potentiometer_Bourns_3296W_Vertical
SW1: RESET; SW_SPST_PTS645
SW2: BOOT; SW_SPST_PTS645
SW3: 5-Way-Navigation-Switch; 5-Way-Nagivation-Switch
U1: AMS1117-3.3; SOT-223-3_TabPin2
U3: STM32F303CCTx; LQFP-48_7x7mm_P0.5mm
Y1: Crystal; Crystal_HC49-4H_Vertical

Connections:
+3V3: C4.1, C13.1, C14.1, C15.1, C16.1, J5.2, J6.4 (VDD), R1.1, R10.1, R11.1, R12.1, R13.1, SW2.2, SW3.6, U1.2 (VO), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD); also elsewhere on the board
+5V: C2.1, C12.1, J1.2, J2.1, J3.1, J4.1 (VBUS), R26.1, U1.3 (VI); also elsewhere on the board
ADC_JACK_L: U3.11 (PA1); also elsewhere on the board
ADC_JACK_R: U3.10 (PA0); also elsewhere on the board
ADC_MIC: U3.19 (PB1); also elsewhere on the board
AUX1: J7.1, U3.30 (PA9)
AUX2: J7.2, U3.31 (PA10)
BOOT0: C3.1, R2.1, SW2.1, U3.44 (BOOT0)
DISPLAY_BLK!: J5.8, U3.22 (PB11)
DISPLAY_CS: J5.7, U3.14 (PA4)
DISPLAY_DC: J5.6, U3.21 (PB10)
DISPLAY_MOSI: J5.4, U3.17 (PA7)
DISPLAY_RES: J5.5, U3.20 (PB2)
DISPLAY_SCK: J5.3, U3.15 (PA5)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J1.1, J2.4, J3.4, J4.4 (GND), J4.5 (Shield), J5.1, J6.6 (VSS), J6.11 (DET_A/SHIELD), J7.3, J7.4, R2.2, RV1.2, SW1.1, U1.1 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS); also elsewhere on the board
IN_CENTER: C9.1, R6.1, U3.46 (PB9)
IN_DOWN: C7.1, R4.1, U3.2 (PC13)
IN_LEFT: C8.1, R5.1, U3.3 (PC14)
IN_RIGHT: C11.1, R7.1, U3.45 (PB8)
IN_UP: C5.1, R3.1, U3.4 (PC15)
LASER_PWM: U3.29 (PA8); also elsewhere on the board
LDR_DETECT: R13.2, RV1.1, U3.18 (PB0)
NRST: C1.1, R1.2, SW1.2, U3.7 (NRST)
unnamed: C6.2, U3.5 (PF0), Y1.1
unnamed: C10.2, U3.6 (PF1), Y1.2
unnamed: J4.2 (D-), R9.1
unnamed: J4.3 (D+), R8.1, R26.2
unnamed: R3.2, SW3.1
unnamed: R4.2, SW3.3
unnamed: R5.2, SW3.2
unnamed: R6.2, SW3.4
unnamed: R7.2, SW3.5
RX: J3.3, U3.13 (PA3)
SD_CS: J6.2 (DAT3/CD), R12.2, U3.25 (PB12)
SD_Detect: J6.9 (DET_B), U3.16 (PA6)
SD_MISO: J6.7 (DAT0), R10.2, U3.27 (PB14)
SD_MOSI: J6.3 (CMD), R11.2, U3.28 (PB15)
SD_SCK: J6.5 (CLK), U3.26 (PB13)
SWDCLK: J2.2, U3.37 (PA14)
SWDIO: J2.3, U3.34 (PA13)
TX: J3.2, U3.12 (PA2)
USB_DM: R9.2, U3.32 (PA11)
USB_DP: R8.2, U3.33 (PA12)
X_DIR: U3.42 (PB6); also elsewhere on the board
X_EN: U3.43 (PB7); also elsewhere on the board
X_STEP: U3.41 (PB5); also elsewhere on the board
Y_DIR: U3.39 (PB3); also elsewhere on the board
Y_EN: U3.40 (PB4); also elsewhere on the board
Y_STEP: U3.38 (PA15); also elsewhere on the board

Notes on the sheet:
Reset and Boot
SWD
UART
USB
MicroSD card
LCD
Buttons
LDR
Power

Parts:
C17, C18, C21: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C19, C20: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J8: HEADPHONES; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical_RST_AUDIO
MK1: Mic; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R14, R15, R16, R17, R19: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R18: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV2: 10k; Potentiometer_Bourns_3296W_Vertical
U4: LM321; SOT-23-5

Connections:
+3V3: R14.1, R16.1, R18.1; also elsewhere on the board
+5V: U4.5 (V+); also elsewhere on the board
ADC_JACK_L: C17.1, C19.2, R14.2, R15.1; also elsewhere on the board
ADC_JACK_R: C18.1, C20.2, R16.2, R17.1; also elsewhere on the board
ADC_MIC: RV2.3, U4.4; also elsewhere on the board
GND: C19.1, C20.1, J8.S, MK1.1 (-), R15.2, R17.2, R19.2, RV2.1, U4.2 (V-); also elsewhere on the board
unnamed: C17.2, J8.T
unnamed: C18.2, J8.R
unnamed: C21.1, R19.1, U4.1 (+)
unnamed: C21.2, MK1.2 (+), R18.2
unnamed: RV2.2, U4.3 (-)

Notes on the sheet:
Headphone Input
Microphone Input

Parts:
J9: MOTOR_X; PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal
J10: MOTOR_Y; PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal
J11: LASER; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7: Si2300; SOT-23
R20, R21, R22, R23, R24, R25: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
+5V: J9.1, J10.1, J11.1; also elsewhere on the board
GND: Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S); also elsewhere on the board
LASER_PWM: Q7.1 (G); also elsewhere on the board
unnamed: J9.2, R20.1
unnamed: J9.3, R21.1
unnamed: J9.4, R22.1
unnamed: J10.2, R23.1
unnamed: J10.3, R24.1
unnamed: J10.4, R25.1
unnamed: J11.2, Q7.3 (D)
unnamed: Q1.3 (D), R20.2
unnamed: Q2.3 (D), R21.2
unnamed: Q3.3 (D), R22.2
unnamed: Q4.3 (D), R23.2
unnamed: Q5.3 (D), R24.2
unnamed: Q6.3 (D), R25.2
X_DIR: Q2.1 (G); also elsewhere on the board
X_EN: Q3.1 (G); also elsewhere on the board
X_STEP: Q1.1 (G); also elsewhere on the board
Y_DIR: Q5.1 (G); also elsewhere on the board
Y_EN: Q6.1 (G); also elsewhere on the board
Y_STEP: Q4.1 (G); also elsewhere on the board

Notes on the sheet:
Motors
Laser

Board: 2 copper layers, 84.8 x 89.9 mm, 79 parts (0 on the bottom side), 67 nets.

## Code that names these connections

File Hardware/CubeMX/LaserScanningProjector.ioc (part):

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Mcu.Name=STM32F303C(B-C)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F303CCTx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=ADC_JACK_R
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=ADC_JACK_L
PA1.Mode=IN2-Single-Ended
PA1.Signal=ADC1_IN2
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=AUX2
PA10.Signal=GPIO_Output
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=Y_STEP
PA15.Signal=GPIO_Output
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=DISPLAY_CS
PA4.Mode=NSS_Signal_Hard_Output
PA4.Signal=SPI1_NSS
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=DISPLAY_SCK
PA5.Mode=Simplex_Bidirectional_Master
PA5.Signal=SPI1_SCK
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=SD_DETECT
PA6.Signal=GPIO_Input
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=DISPLAY_MOSI
PA7.Mode=Simplex_Bidirectional_Master
PA7.Signal=SPI1_MOSI
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=LASER_PWM
PA8.Signal=S_TIM1_CH1
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=AUX1
PA9.Signal=GPIO_Output
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=LDR_DETECT
PB0.Signal=GPIO_Input
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=ADC_MIC
PB1.Mode=IN1-Single-Ended
PB1.Signal=ADC3_IN1
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=DISPLAY_DC
PB10.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=DISPLAY_BLK\!
PB11.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=SD_CS
PB12.Mode=NSS_Signal_Hard_Output
PB12.Signal=SPI2_NSS
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=SD_SCK
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=SD_MISO
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=SD_MOSI
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=DISPLAY_RES
PB2.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=Y_DIR
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=Y_EN
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=X_STEP
PB5.Signal=S_TIM3_CH2
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=X_DIR
PB6.Signal=GPIO_Output
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=X_EN
PB7.Signal=GPIO_Output
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=IN_RIGHT
PB8.Signal=GPIO_Input
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=IN_CENTER
PB9.Signal=GPIO_Input
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=IN_DOWN
PC13.Signal=GPIO_Input
PC14-OSC32_IN.GPIOParameters=GPIO_Label
PC14-OSC32_IN.GPIO_Label=IN_LEFT
PC14-OSC32_IN.Signal=GPIO_Input
PC15-OSC32_OUT.GPIOParameters=GPIO_Label
PC15-OSC32_OUT.GPIO_Label=IN_UP
PC15-OSC32_OUT.Signal=GPIO_Input
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2019-10-27 Adding production documents
2019-10-27 Update schematic metadata
2019-10-27 Initial commit for software project
2019-10-28 Minor changes to hardware
    - Changed laser power supply from 3v3 to 5v
    - 5v for more flexibility in laser diode selection
    - Bumped revision number to v1.0
    - Added version number to PCB
2019-10-28 Adding zip files to .gitignore
2019-11-01 Add driver for motors
2019-11-01 Initial abstraction layer for peripherals
2019-11-02 Migrate to new stepper motor driver
    Finished implementing do_steps()
2019-11-03 Fix typo in silkscreen; Display BL -> PB11
2019-11-05 Adding gdb flash target
2019-11-05 Add function to set gpio to alternate function
2019-11-05 Initial working implementation of lcd driver
2019-11-05 Add example code to drive lcd
2019-11-05 Add docs to lcd driver
2019-11-05 Implement lcd draw pixel
2019-11-05 Swap center and right pins on 5 dir nav switch
2019-11-07 Implement laser driver
2019-11-07 Fix inverted brightness percent
2019-11-11 Implement laser_canvas; Implement laser homing;
2019-11-11 Always step x motor when detected by ldr
    Step the x off the ldr so it doesnt immediately trigger the check in next stage
2019-11-11 Set origin after homing
2019-11-11 Rename laser_canvas members
2019-11-11 Add getters for some laser_canvas properties
2019-11-11 Implement goto_xy for laser_canvas
2019-11-16 Change starting position of laser canvas
    Move the laser slightly out of the ldr way then go to center
2019-11-16 Upload test code for various stuff
2019-11-16 Do not initialize laser canvas during object construction
    Causes a long delay before the LCD actually works.
2019-11-16 Simple refactor
2019-11-16 [lcd] Add ability to display characters and strings
2019-11-16 Add lvgl lib
2019-11-16 Implement ui driver
2019-11-16 Implement 5 way nav switch driver
2019-11-16 Pass new state to pin external interrupt callbacks
2019-11-16 Implement ui input driver
2019-11-16 Fix left, right buttons not working
2019-11-16 Save pointers to display and input device in ui instance
2019-11-16 Add ui button input example code to main
2019-11-16 Fix nav5 read return
2019-11-17 Refactor gpio
2019-11-17 Make ui fully static
2019-11-19 Move LVGL location and fix incorrect flags for LVGL
    - Moves the LVGL submodule to follow "one CMakeLists.txt per target" rule
    - Adds appropriate flags to LVGL to reduce binary size by 25%
2019-11-19 Add fatfs lib; Add stubs
2019-11-19 Add some more test ui code
2019-11-19 Fix LVGL target_include_directories path
    LVGL has an odd directory structure, with both the root and src
    containing headers. We fix this by adding both paths to
    target_include_directories.
2019-11-19 Use add_subdirectory for fatfs library
2019-11-19 Fix erroneous file in CMakeLists.txt
    The file is still a WIP.
2019-11-23 Use new offset for new lcd
2019-11-23 WIP: UI wrapper classes
2019-11-23 Implement USART lib
2019-11-23 Implement USART string recv
2019-11-23 Abstract LVGL to C++ classes
2019-11-23 Not using std::string in USART
2019-11-23 Add pull-up resistor to usb dp
2019-11-23 Delay needed between step pulses
2019-11-23 Update bounds check for canvas
2019-11-23 Add function to highlight canvas area
2019-11-24 Complete USB-CDCACM implementation
2019-11-24 Add rendering for a checkerbox pattern
2019-11-24 Turn off animations
2019-11-24 Add fit function to container
2019-11-24 Push ui task handler to timer
2019-11-24 Temporarily disable laser_canvas frame check
2019-11-24 Add handle constructor to button
2019-11-24 Add more wrapper functions to lvgl object
2019-11-24 Add lvgl list wrapper
2019-11-24 Implement view_main and view_basic
2019-11-24 Add missing return in list add_btn
2019-11-24 Give lvgl more ram to work
    Crashes after adding more ui elements because it cant allocate enough ram
2019-11-24 Refactor main code
2019-11-24 Implement view_debug
2019-11-24 Move ui timer init to end of init routine
2019-11-24 Add clear function to laser_canvas
2019-11-24 Add text_align to label wrapper
2019-11-24 Add del to object wrapper
2019-11-24 Implement view_init
2019-11-24 Set views init to private
2019-11-27 Set ui interrupt to lower priority
2019-11-27 Add raw handle constructors for list and label
2019-11-27 Implement mic audio render
2019-11-27 Disable mic mode properly when returning to main menu
2019-11-27 Set rendering off by default
2019-11-30 Add option to skip homing
2019-11-30 Initial implementation for bitmap and tuple rendering
2019-11-30 Various changes
    - Poll USB using timer
    - Use staggered rendering to reduce artifacting
2019-11-30 Fix mic value equation
2019-11-30 Add canvas resize functions
2019-11-30 Resize canvas in mic mode
2019-12-04 Initial working copy of USB streaming
2019-12-04 [software] Tweak USB tuple parameters
2019-12-04 [software-pc] Add image loading
2019-12-04 Add view_usb
2019-12-04 [software] Add manual mode and fix infinite loop in PC software
2019-12-04 Add mode changes for headphone
2019-12-04 [software] usb: Fix image cutoff issue
    It turns out that it is because when doubling the resolution, I forgot to bump the packet format to uint16_t.
2019-12-04 Fix issue where transition from USB to other modes causes unsigned underflow
2019-12-04 Implement headphone rendering
2019-12-04 [software] Add documentation and mass reformat code
2019-12-10 [report] Initial commit with example
2019-12-17 Fill in content for the report
2019-12-19 Added photos to html report
